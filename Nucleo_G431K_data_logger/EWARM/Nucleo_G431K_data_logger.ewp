# IAR project Nucleo_G431K_data_logger.ewp, settings and files
configuration Nucleo_G431K_data_logger (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431KB ST STM32G431KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ..\user_code; ..\user_code\ai
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Nucleo_G431K_data_logger.hex
  ILINK.IlinkOutputFile: Nucleo_G431K_data_logger.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\user_code\ai\libneai.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User/ai
    ../user_code/ai/: knowledge.h NanoEdgeAI.h
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
    ../Core/Inc/: main.h stm32g4xx_hal_conf.h stm32g4xx_it.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c

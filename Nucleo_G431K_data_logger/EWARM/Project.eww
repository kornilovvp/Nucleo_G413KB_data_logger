<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo_G431K_data_logger.ewp</path>
  </project>
  <batchBuild />
</workspace>
